# Keil uVision project Smpl_DrvADC.uvproj, settings and files
target 29'Display_MainBoard_V21 (ARM-ADS)
  device: M058LDN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: 29'Display_MainBoard_V21 +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 wLevel=1
  c include: .\USER;.\Library\CM0\CoreSupport;.\Library\CM0\DeviceSupport\Nuvoton\M051Series;.\Library\Include\Driver;.\Library\Include\M051-LB_004;.\Library\Include\System
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ./Library/CM0/CoreSupport/: core_cm0.c
    ./Library/CM0/DeviceSupport/Nuvoton/M051Series/: system_M051Series.c
    ./Library/CM0/DeviceSupport/Nuvoton/M051Series/startup/arm/: startup_M051Series.s
  group Source files
    ./USER/: ADC.c GPIO.c main.c PWM.c UART.c Timer.c IIC.C
  group Library files
    ./Library/Src/Driver/: DrvADC.c DrvEBI.c DrvFMC.c DrvGPIO.c DrvI2C.c DrvPWM.c DrvSPI.c DrvSYS.c DrvTIMER.c DrvUART.c retarget.c
  group Header
    ./USER/: global.h TempCodeDef.h
